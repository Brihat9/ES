; FINDING FACTORIAL OF NUMBER STORED IN REG R3 AND DISPLAY IN DECIMAL FORMAT

		ORG 00H
		
		MOV R3,#05H
		
		MOV B,R3
		MOV R1,B
		
		ACALL FACTO
		
		MOV R1,A
AGAIN:	MOV A,R1
		MOV P0,A
		ACALL DELAY
		
		ACALL HTOD
		MOV P0,A
		ACALL DELAY
		
		MOV A,B
		MOV P0,A
		ACALL DELAY
		SJMP AGAIN
		
HTOD:	MOV R4,#00H
		MOV B,#0AH
		DIV AB
		MOV R2,A
		SUBB A,#0AH
		JC SKIP
		MOV A,R2
		MOV R3,B
		MOV B,#0AH
		DIV AB
		MOV R4,A
		MOV P0,A
		MOV A,B
		MOV B,R3
		MOV R2,A
SKIP:	MOV A,R2
		SWAP A
		ADD A,B
		MOV B,R4
		RET
		
DELAY: 	MOV R7,#7
HERE1:	MOV R6,#255
HERE2: 	MOV R5,#255
HERE3:	DJNZ R5,HERE3
		DJNZ R6,HERE2
		DJNZ R7,HERE1
		RET

FACTO:	MOV A,#01H
LOOP:	MOV B,R1
		MUL AB
		DJNZ R1,LOOP
		RET		
		END
		