; multiply using successive addition

		ORG 00H
		
		MOV 22H,#0FFH
		MOV 15H,#0DEH
		
		MOV A,#0H
		MOV R1,#0H
		
		MOV R0,51H
AGAIN:	ADD A,50H
		JNC SKIP
		INC R1
SKIP:	DJNZ R0,AGAIN

		MOV 19H,A
		MOV 1AH,R1
		
LOOP:	MOV P0,A
		ACALL DELAY
		MOV P0,R1
		ACALL DELAY
		AJMP LOOP

DELAY: 	MOV R4,#7
HERE1:	MOV R5,#255
HERE2: 	MOV R7,#255
HERE3:	DJNZ R7,HERE3
		DJNZ R5,HERE2
		DJNZ R4,HERE1
		RET
		
		END
		