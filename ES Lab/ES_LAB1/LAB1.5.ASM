; find smallest and largest among given data

		ORG 00H
		
		MOV 50H,#0D6H
		MOV 51H,#0F2H
		MOV 52H,#0E4H
		MOV 53H,#0A8H
		MOV 54H,#0CEH
		MOV 55H,#0B9H
		MOV 56H,#0FAH
		MOV 57H,#0AEH
		MOV 58H,#0BAH
		MOV 59H,#0CCH
		
		MOV R0,#50H
		
		MOV A,@R0
		MOV R7,A	;SMALLEST
		MOV R1,A	;LARGEST
		
		MOV R2,#09H
		
NEXT:	INC R0
		MOV A,R7
		SUBB A,@R0
		JNC NO_SMALL
		MOV A,@R0
		MOV R7,A
NO_SMALL:	MOV A,R1
		SUBB A,@R0
		JC NO_BIG
		MOV A,@R0
		MOV R1,A
NO_BIG:	DJNZ R2,NEXT

LOOP:	MOV P0,R7
		ACALL DELAY
		MOV P0,R1
		ACALL DELAY
		AJMP LOOP

DELAY: 	MOV R3,#7
HERE1:	MOV R4,#255
HERE2: 	MOV R5,#255
HERE3:	DJNZ R5,HERE3
		DJNZ R4,HERE2
		DJNZ R3,HERE1
		RET
		
		END
		