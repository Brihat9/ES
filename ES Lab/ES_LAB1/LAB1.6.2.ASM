; arrange given data in descending order implementing selecction sort algoriothm
		ORG 00H

; GIVEN DATA
		MOV 60H,#0A5H
		MOV 61H,#0FDH
		MOV 62H,#67H
		MOV 63H,#42H
		MOV 64H,#0DFH
		MOV 65H,#9AH
		MOV 66H,#84H
		MOV 67H,#1BH
		MOV 68H,#0C7H
		MOV 69H,#31H
		
; MAIN ROUTINE
		MOV R0,#60H ;base address
		MOV R6,#09H ;counter = no of given data - 1
AGN:	ACALL F_LARGE
		MOV @R0,A
		INC R0
		DJNZ R6,AGN

; DISPLAY SORTED LIST
AGAIN:	MOV R1,#0AH
		MOV R0,#60H
LOOP:	MOV A,@R0
		MOV P0,A
		ACALL DELAY
		INC R0
		DJNZ R1,LOOP
		AJMP AGAIN
		
; SELECTION SORT ALGORITHM		
F_LARGE:MOV B,R0
		MOV A,R6 ;COUNTER MAIN
		MOV R2,A ;COUNTER 2
	
		MOV A,@R0
		MOV R1,A ;R1 HOLDS LARGEST VALUE
		
NEXT:	INC R0
		MOV R4,A ;save A
		SUBB A,@R0
		JNC SKIP
		
		MOV A,@R0 ;ACC=LARGEST NOW
		MOV R1,A;R1=LARGEST NOW
		MOV A,R4
		MOV @R0,A;XCHG A AND @R0
		
SKIP:	MOV A,R1;ACC- LARGEST
		DJNZ R2,NEXT
		MOV R0,B
		RET

; DELAY ROUTINE
DELAY: 	MOV R3,#7
HERE1:	MOV R4,#255
HERE2: 	MOV R5,#255
HERE3:	DJNZ R5,HERE3
		DJNZ R4,HERE2
		DJNZ R3,HERE1
		RET
		
		END