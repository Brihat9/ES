; find prime numbers between prime numbers

		ORG 00H
		
		MOV R0,#40H
		MOV A,#00H
AGAIN:	MOV @R0,A
		INC A
		INC R0
		MOV R1,A
		SUBB A,#20H
;		JZ DONE
		JZ DONE2
		MOV A,R1
		AJMP AGAIN
			
;DONE:	MOV R0,#40H
;DISPL:	MOV A,@R0
;		MOV P0,A
;		ACALL DELAY
;		INC R0
;		AJMP DISPL
		
DONE2:	MOV A,42H
		MOV P0,A
		ACALL DELAY
		MOV A,43H
		MOV P0,A
		ACALL DELAY

		MOV R0,#44H
		MOV R1,#1DH ; TOTAL NO - 1 - 1 - 1 - 1 = TOTAL - 4
NEXT:	ACALL PRIME	
		INC R0
		DJNZ R1,NEXT
		AJMP DONE2
	
PRIME:	MOV A,@R0
		MOV R4,A ; SAVE A
		
		MOV R2,#02H
INC_B:	MOV A,R4
		MOV B,R2		
		DIV AB
		
		MOV A,B
		
		JNZ N_RET
		RET
N_RET:	INC R2
		MOV A,R2
		SUBB A,@R0
		JNZ INC_B
		MOV A,R4
		MOV P0,A
		ACALL DELAY
		RET

DELAY: 	MOV R7,#7
HERE1:	MOV R6,#255
HERE2: 	MOV R5,#255
HERE3:	DJNZ R5,HERE3
		DJNZ R6,HERE2
		DJNZ R7,HERE1
		RET
		
		END
		