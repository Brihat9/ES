;GENERATE MULTIPLICATION TABLE
		ORG 00H
		
		MOV R7,#7 ; NUMBER
		MOV P2,#00H
		MOV DPTR,#LABEL1

		MOV B,R7
		MOV R0,#5AH
		MOV R6,#10
AGN:	MOV B,R6
		MOV A,R7
		MUL AB
		MOV @R0,A
		DEC R0
		DJNZ R6,AGN
		
;HEX TO DEC CONVERTER
		MOV R0,#51H
		MOV R6,#10
		
AGN2:	MOV A,@R0
		MOV R4,#00H
		MOV B,#0AH
		DIV AB
		MOV R2,A
		SUBB A,#0AH
		JC SKIP
		MOV A,R2
		MOV R3,B
		MOV B,#0AH
		DIV AB
		MOV R4,A
		MOV A,B
		MOV B,R3
		MOV R2,A
SKIP:	MOV A,R2
		SWAP A
		ADD A,B
		MOV B,R4
		
		MOV @R0,A
		INC R0
		DJNZ R6,AGN2
		
; DISPLAY
REPEAT:	MOV R0,#51H
		MOV R4,#10
LOOP1:	MOV R7,#255
MAIN:	MOV A,@R0
		MOV B,A
		ANL A,#0FH
		MOV P2,#02H
		ACALL DISPLAY
		MOV P0,A
		ACALL DELAY
		MOV A,B
		ANL A,#0F0H
		SWAP A
		MOV P2,#01H
		ACALL DISPLAY
		MOV P0,A
		ACALL DELAY
		DJNZ R7,MAIN
		INC R0
		DJNZ R4,LOOP1
		AJMP REPEAT
						
DELAY:	MOV R3,#02H
DEL1:	MOV R2,#0FAH
DEL2:	DJNZ R2,DEL2
		DJNZ R3,DEL1
		RET

;CHOOSE REQUIRED PATTERN
DISPLAY:MOVC A,@A+DPTR
		RET

;LED PATTERNS FOR NUMBERS 0-9
LABEL1:	DB 3FH
		DB 06H
		DB 5BH
		DB 4FH
		DB 66H
		DB 6DH
		DB 7DH
		DB 07H
		DB 7FH
		DB 6FH

		END