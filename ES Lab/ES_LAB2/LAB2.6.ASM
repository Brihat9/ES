;SCROLLING DISPLAY OF ROLL NUMBER

		ORG 00H
;C513		
		MOV 40H,#39H
		MOV 41H,#6DH
		MOV 42H,#06H
		MOV 43H,#0CFH
;C514		
		MOV 44H,#39H
		MOV 45H,#6DH
		MOV 46H,#06H
		MOV 47H,#0E6H
;C515		
		MOV 48H,#39H
		MOV 49H,#6DH
		MOV 4AH,#06H
		MOV 4BH,#0EDH
;C516		
		MOV 4CH,#39H
		MOV 4DH,#6DH
		MOV 4EH,#06H
		MOV 4FH,#0FDH
;C51		
		MOV 50H,#39H
		MOV 51H,#6DH
		MOV 52H,#06H
		

; DISPLAY
REPEAT:	MOV R0,#40H
		MOV R4,#10H
LOOP1:	MOV R7,#255
MAIN:	MOV A,@R0
		SETB P2.0
		MOV P0,A
		ACALL DELAY
		CLR P2.0
		INC R0
		
		MOV A,@R0
		SETB P2.1
		MOV P0,A
		ACALL DELAY
		CLR P2.1
		INC R0
		
		MOV A,@R0
		SETB P2.2
		MOV P0,A
		ACALL DELAY
		CLR P2.2
		INC R0
		
		MOV A,@R0
		SETB P2.3
		MOV P0,A
		ACALL DELAY
		CLR P2.3
		
		DEC R0
		DEC R0
		DEC R0
		
		DJNZ R7,MAIN
		
		INC R0
		DJNZ R4,LOOP1
		AJMP REPEAT
						
DELAY:	MOV R3,#02H
DEL1:	MOV R2,#0FAH
DEL2:	DJNZ R2,DEL2
		DJNZ R3,DEL1
		RET
				
		END
		